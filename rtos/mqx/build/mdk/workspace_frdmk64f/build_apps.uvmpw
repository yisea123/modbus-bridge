<?xml version="1.0" encoding="UTF-8" standalone="no"?>
<ProjectWorkspace xmlns:xsi="http://www.w3.org/2001/XMLSchema-instance" xsi:noNamespaceSchemaLocation="project_mpw.xsd">
  <SchemaVersion>1.0</SchemaVersion>
  <Header>### uVision Project, (C) Keil Software</Header>
  <WorkspaceName>WorkSpace</WorkspaceName>
<project><PathAndName>..\..\..\mqx\examples\watchdog_lite\build\mdk\watchdog_lite_frdmk64f\watchdog_lite_frdmk64f.uvprojx</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\mqx\examples\watchdog\build\mdk\watchdog_frdmk64f\watchdog_frdmk64f.uvprojx</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\mqx\examples\timer\build\mdk\timer_frdmk64f\timer_frdmk64f.uvprojx</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\mqx\examples\test\build\mdk\test_frdmk64f\test_frdmk64f.uvprojx</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\mqx\examples\taskq_lite\build\mdk\taskq_lite_frdmk64f\taskq_lite_frdmk64f.uvprojx</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\mqx\examples\taskq\build\mdk\taskq_frdmk64f\taskq_frdmk64f.uvprojx</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\mqx\examples\taskat\build\mdk\taskat_frdmk64f\taskat_frdmk64f.uvprojx</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\mqx\examples\sem_lite\build\mdk\sem_lite_frdmk64f\sem_lite_frdmk64f.uvprojx</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\mqx\examples\sem\build\mdk\sem_frdmk64f\sem_frdmk64f.uvprojx</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\mqx\examples\nill_lite\build\mdk\nill_lite_frdmk64f\nill_lite_frdmk64f.uvprojx</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\mqx\examples\nill\build\mdk\nill_frdmk64f\nill_frdmk64f.uvprojx</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\mqx\examples\mutex_lite\build\mdk\mutex_lite_frdmk64f\mutex_lite_frdmk64f.uvprojx</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\mqx\examples\mutex\build\mdk\mutex_frdmk64f\mutex_frdmk64f.uvprojx</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\mqx\examples\msg_lite\build\mdk\msg_lite_frdmk64f\msg_lite_frdmk64f.uvprojx</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\mqx\examples\msg\build\mdk\msg_frdmk64f\msg_frdmk64f.uvprojx</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\mqx\examples\lwsem_lite\build\mdk\lwsem_lite_frdmk64f\lwsem_lite_frdmk64f.uvprojx</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\mqx\examples\lwsem\build\mdk\lwsem_frdmk64f\lwsem_frdmk64f.uvprojx</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\mqx\examples\lwmsgq_lite\build\mdk\lwmsgq_lite_frdmk64f\lwmsgq_lite_frdmk64f.uvprojx</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\mqx\examples\lwmsgq\build\mdk\lwmsgq_frdmk64f\lwmsgq_frdmk64f.uvprojx</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\mqx\examples\lwlog_lite\build\mdk\lwlog_lite_frdmk64f\lwlog_lite_frdmk64f.uvprojx</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\mqx\examples\lwlog\build\mdk\lwlog_frdmk64f\lwlog_frdmk64f.uvprojx</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\mqx\examples\lwevent_lite\build\mdk\lwevent_lite_frdmk64f\lwevent_lite_frdmk64f.uvprojx</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\mqx\examples\lwevent\build\mdk\lwevent_frdmk64f\lwevent_frdmk64f.uvprojx</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\mqx\examples\lwdemo_lite\build\mdk\lwdemo_lite_frdmk64f\lwdemo_lite_frdmk64f.uvprojx</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\mqx\examples\lwdemo\build\mdk\lwdemo_frdmk64f\lwdemo_frdmk64f.uvprojx</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\mqx\examples\log_lite\build\mdk\log_lite_frdmk64f\log_lite_frdmk64f.uvprojx</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\mqx\examples\log\build\mdk\log_frdmk64f\log_frdmk64f.uvprojx</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\mqx\examples\klog_lite\build\mdk\klog_lite_frdmk64f\klog_lite_frdmk64f.uvprojx</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\mqx\examples\klog\build\mdk\klog_frdmk64f\klog_frdmk64f.uvprojx</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\mqx\examples\isr_lite\build\mdk\isr_lite_frdmk64f\isr_lite_frdmk64f.uvprojx</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\mqx\examples\isr\build\mdk\isr_frdmk64f\isr_frdmk64f.uvprojx</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\mqx\examples\hello_lite\build\mdk\hello_lite_frdmk64f\hello_lite_frdmk64f.uvprojx</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\mqx\examples\hello\build\mdk\hello_frdmk64f\hello_frdmk64f.uvprojx</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\mqx\examples\event_lite\build\mdk\event_lite_frdmk64f\event_lite_frdmk64f.uvprojx</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\mqx\examples\event\build\mdk\event_frdmk64f\event_frdmk64f.uvprojx</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\mqx\examples\demo_lite\build\mdk\demo_lite_frdmk64f\demo_lite_frdmk64f.uvprojx</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\mqx\examples\demo\build\mdk\demo_frdmk64f\demo_frdmk64f.uvprojx</PathAndName><NodeIsActive>0</NodeIsActive></project></ProjectWorkspace>
