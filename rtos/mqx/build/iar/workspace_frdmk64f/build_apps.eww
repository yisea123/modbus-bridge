<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
<batchBuild><batchDefinition><name>int flash debug</name><member><project>watchdog_lite_frdmk64f</project><configuration>int flash debug</configuration></member><member><project>watchdog_frdmk64f</project><configuration>int flash debug</configuration></member><member><project>timer_frdmk64f</project><configuration>int flash debug</configuration></member><member><project>test_frdmk64f</project><configuration>int flash debug</configuration></member><member><project>taskq_lite_frdmk64f</project><configuration>int flash debug</configuration></member><member><project>taskq_frdmk64f</project><configuration>int flash debug</configuration></member><member><project>taskat_frdmk64f</project><configuration>int flash debug</configuration></member><member><project>sem_lite_frdmk64f</project><configuration>int flash debug</configuration></member><member><project>sem_frdmk64f</project><configuration>int flash debug</configuration></member><member><project>nill_lite_frdmk64f</project><configuration>int flash debug</configuration></member><member><project>nill_frdmk64f</project><configuration>int flash debug</configuration></member><member><project>mutex_lite_frdmk64f</project><configuration>int flash debug</configuration></member><member><project>mutex_frdmk64f</project><configuration>int flash debug</configuration></member><member><project>msg_lite_frdmk64f</project><configuration>int flash debug</configuration></member><member><project>msg_frdmk64f</project><configuration>int flash debug</configuration></member><member><project>lwsem_lite_frdmk64f</project><configuration>int flash debug</configuration></member><member><project>lwsem_frdmk64f</project><configuration>int flash debug</configuration></member><member><project>lwmsgq_lite_frdmk64f</project><configuration>int flash debug</configuration></member><member><project>lwmsgq_frdmk64f</project><configuration>int flash debug</configuration></member><member><project>lwlog_lite_frdmk64f</project><configuration>int flash debug</configuration></member><member><project>lwlog_frdmk64f</project><configuration>int flash debug</configuration></member><member><project>lwevent_lite_frdmk64f</project><configuration>int flash debug</configuration></member><member><project>lwevent_frdmk64f</project><configuration>int flash debug</configuration></member><member><project>lwdemo_lite_frdmk64f</project><configuration>int flash debug</configuration></member><member><project>lwdemo_frdmk64f</project><configuration>int flash debug</configuration></member><member><project>log_lite_frdmk64f</project><configuration>int flash debug</configuration></member><member><project>log_frdmk64f</project><configuration>int flash debug</configuration></member><member><project>klog_lite_frdmk64f</project><configuration>int flash debug</configuration></member><member><project>klog_frdmk64f</project><configuration>int flash debug</configuration></member><member><project>isr_lite_frdmk64f</project><configuration>int flash debug</configuration></member><member><project>isr_frdmk64f</project><configuration>int flash debug</configuration></member><member><project>hello_lite_frdmk64f</project><configuration>int flash debug</configuration></member><member><project>hello_frdmk64f</project><configuration>int flash debug</configuration></member><member><project>event_lite_frdmk64f</project><configuration>int flash debug</configuration></member><member><project>event_frdmk64f</project><configuration>int flash debug</configuration></member><member><project>demo_lite_frdmk64f</project><configuration>int flash debug</configuration></member><member><project>demo_frdmk64f</project><configuration>int flash debug</configuration></member></batchDefinition><batchDefinition><name>all</name><member><project>watchdog_lite_frdmk64f</project><configuration>int flash debug</configuration></member><member><project>watchdog_lite_frdmk64f</project><configuration>int flash release</configuration></member><member><project>watchdog_frdmk64f</project><configuration>int flash debug</configuration></member><member><project>watchdog_frdmk64f</project><configuration>int flash release</configuration></member><member><project>timer_frdmk64f</project><configuration>int flash debug</configuration></member><member><project>timer_frdmk64f</project><configuration>int flash release</configuration></member><member><project>test_frdmk64f</project><configuration>int flash debug</configuration></member><member><project>test_frdmk64f</project><configuration>int flash release</configuration></member><member><project>taskq_lite_frdmk64f</project><configuration>int flash debug</configuration></member><member><project>taskq_lite_frdmk64f</project><configuration>int flash release</configuration></member><member><project>taskq_frdmk64f</project><configuration>int flash debug</configuration></member><member><project>taskq_frdmk64f</project><configuration>int flash release</configuration></member><member><project>taskat_frdmk64f</project><configuration>int flash debug</configuration></member><member><project>taskat_frdmk64f</project><configuration>int flash release</configuration></member><member><project>sem_lite_frdmk64f</project><configuration>int flash debug</configuration></member><member><project>sem_lite_frdmk64f</project><configuration>int flash release</configuration></member><member><project>sem_frdmk64f</project><configuration>int flash debug</configuration></member><member><project>sem_frdmk64f</project><configuration>int flash release</configuration></member><member><project>nill_lite_frdmk64f</project><configuration>int flash debug</configuration></member><member><project>nill_lite_frdmk64f</project><configuration>int flash release</configuration></member><member><project>nill_frdmk64f</project><configuration>int flash debug</configuration></member><member><project>nill_frdmk64f</project><configuration>int flash release</configuration></member><member><project>mutex_lite_frdmk64f</project><configuration>int flash debug</configuration></member><member><project>mutex_lite_frdmk64f</project><configuration>int flash release</configuration></member><member><project>mutex_frdmk64f</project><configuration>int flash debug</configuration></member><member><project>mutex_frdmk64f</project><configuration>int flash release</configuration></member><member><project>msg_lite_frdmk64f</project><configuration>int flash debug</configuration></member><member><project>msg_lite_frdmk64f</project><configuration>int flash release</configuration></member><member><project>msg_frdmk64f</project><configuration>int flash debug</configuration></member><member><project>msg_frdmk64f</project><configuration>int flash release</configuration></member><member><project>lwsem_lite_frdmk64f</project><configuration>int flash debug</configuration></member><member><project>lwsem_lite_frdmk64f</project><configuration>int flash release</configuration></member><member><project>lwsem_frdmk64f</project><configuration>int flash debug</configuration></member><member><project>lwsem_frdmk64f</project><configuration>int flash release</configuration></member><member><project>lwmsgq_lite_frdmk64f</project><configuration>int flash debug</configuration></member><member><project>lwmsgq_lite_frdmk64f</project><configuration>int flash release</configuration></member><member><project>lwmsgq_frdmk64f</project><configuration>int flash debug</configuration></member><member><project>lwmsgq_frdmk64f</project><configuration>int flash release</configuration></member><member><project>lwlog_lite_frdmk64f</project><configuration>int flash debug</configuration></member><member><project>lwlog_lite_frdmk64f</project><configuration>int flash release</configuration></member><member><project>lwlog_frdmk64f</project><configuration>int flash debug</configuration></member><member><project>lwlog_frdmk64f</project><configuration>int flash release</configuration></member><member><project>lwevent_lite_frdmk64f</project><configuration>int flash debug</configuration></member><member><project>lwevent_lite_frdmk64f</project><configuration>int flash release</configuration></member><member><project>lwevent_frdmk64f</project><configuration>int flash debug</configuration></member><member><project>lwevent_frdmk64f</project><configuration>int flash release</configuration></member><member><project>lwdemo_lite_frdmk64f</project><configuration>int flash debug</configuration></member><member><project>lwdemo_lite_frdmk64f</project><configuration>int flash release</configuration></member><member><project>lwdemo_frdmk64f</project><configuration>int flash debug</configuration></member><member><project>lwdemo_frdmk64f</project><configuration>int flash release</configuration></member><member><project>log_lite_frdmk64f</project><configuration>int flash debug</configuration></member><member><project>log_lite_frdmk64f</project><configuration>int flash release</configuration></member><member><project>log_frdmk64f</project><configuration>int flash debug</configuration></member><member><project>log_frdmk64f</project><configuration>int flash release</configuration></member><member><project>klog_lite_frdmk64f</project><configuration>int flash debug</configuration></member><member><project>klog_lite_frdmk64f</project><configuration>int flash release</configuration></member><member><project>klog_frdmk64f</project><configuration>int flash debug</configuration></member><member><project>klog_frdmk64f</project><configuration>int flash release</configuration></member><member><project>isr_lite_frdmk64f</project><configuration>int flash debug</configuration></member><member><project>isr_lite_frdmk64f</project><configuration>int flash release</configuration></member><member><project>isr_frdmk64f</project><configuration>int flash debug</configuration></member><member><project>isr_frdmk64f</project><configuration>int flash release</configuration></member><member><project>hello_lite_frdmk64f</project><configuration>int flash debug</configuration></member><member><project>hello_lite_frdmk64f</project><configuration>int flash release</configuration></member><member><project>hello_frdmk64f</project><configuration>int flash debug</configuration></member><member><project>hello_frdmk64f</project><configuration>int flash release</configuration></member><member><project>event_lite_frdmk64f</project><configuration>int flash debug</configuration></member><member><project>event_lite_frdmk64f</project><configuration>int flash release</configuration></member><member><project>event_frdmk64f</project><configuration>int flash debug</configuration></member><member><project>event_frdmk64f</project><configuration>int flash release</configuration></member><member><project>demo_lite_frdmk64f</project><configuration>int flash debug</configuration></member><member><project>demo_lite_frdmk64f</project><configuration>int flash release</configuration></member><member><project>demo_frdmk64f</project><configuration>int flash debug</configuration></member><member><project>demo_frdmk64f</project><configuration>int flash release</configuration></member></batchDefinition><batchDefinition><name>int flash release</name><member><project>watchdog_lite_frdmk64f</project><configuration>int flash release</configuration></member><member><project>watchdog_frdmk64f</project><configuration>int flash release</configuration></member><member><project>timer_frdmk64f</project><configuration>int flash release</configuration></member><member><project>test_frdmk64f</project><configuration>int flash release</configuration></member><member><project>taskq_lite_frdmk64f</project><configuration>int flash release</configuration></member><member><project>taskq_frdmk64f</project><configuration>int flash release</configuration></member><member><project>taskat_frdmk64f</project><configuration>int flash release</configuration></member><member><project>sem_lite_frdmk64f</project><configuration>int flash release</configuration></member><member><project>sem_frdmk64f</project><configuration>int flash release</configuration></member><member><project>nill_lite_frdmk64f</project><configuration>int flash release</configuration></member><member><project>nill_frdmk64f</project><configuration>int flash release</configuration></member><member><project>mutex_lite_frdmk64f</project><configuration>int flash release</configuration></member><member><project>mutex_frdmk64f</project><configuration>int flash release</configuration></member><member><project>msg_lite_frdmk64f</project><configuration>int flash release</configuration></member><member><project>msg_frdmk64f</project><configuration>int flash release</configuration></member><member><project>lwsem_lite_frdmk64f</project><configuration>int flash release</configuration></member><member><project>lwsem_frdmk64f</project><configuration>int flash release</configuration></member><member><project>lwmsgq_lite_frdmk64f</project><configuration>int flash release</configuration></member><member><project>lwmsgq_frdmk64f</project><configuration>int flash release</configuration></member><member><project>lwlog_lite_frdmk64f</project><configuration>int flash release</configuration></member><member><project>lwlog_frdmk64f</project><configuration>int flash release</configuration></member><member><project>lwevent_lite_frdmk64f</project><configuration>int flash release</configuration></member><member><project>lwevent_frdmk64f</project><configuration>int flash release</configuration></member><member><project>lwdemo_lite_frdmk64f</project><configuration>int flash release</configuration></member><member><project>lwdemo_frdmk64f</project><configuration>int flash release</configuration></member><member><project>log_lite_frdmk64f</project><configuration>int flash release</configuration></member><member><project>log_frdmk64f</project><configuration>int flash release</configuration></member><member><project>klog_lite_frdmk64f</project><configuration>int flash release</configuration></member><member><project>klog_frdmk64f</project><configuration>int flash release</configuration></member><member><project>isr_lite_frdmk64f</project><configuration>int flash release</configuration></member><member><project>isr_frdmk64f</project><configuration>int flash release</configuration></member><member><project>hello_lite_frdmk64f</project><configuration>int flash release</configuration></member><member><project>hello_frdmk64f</project><configuration>int flash release</configuration></member><member><project>event_lite_frdmk64f</project><configuration>int flash release</configuration></member><member><project>event_frdmk64f</project><configuration>int flash release</configuration></member><member><project>demo_lite_frdmk64f</project><configuration>int flash release</configuration></member><member><project>demo_frdmk64f</project><configuration>int flash release</configuration></member></batchDefinition></batchBuild><project><path>$WS_DIR$\..\..\..\mqx\examples\watchdog_lite\build\iar\watchdog_lite_frdmk64f\watchdog_lite_frdmk64f.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\watchdog\build\iar\watchdog_frdmk64f\watchdog_frdmk64f.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\timer\build\iar\timer_frdmk64f\timer_frdmk64f.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\test\build\iar\test_frdmk64f\test_frdmk64f.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\taskq_lite\build\iar\taskq_lite_frdmk64f\taskq_lite_frdmk64f.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\taskq\build\iar\taskq_frdmk64f\taskq_frdmk64f.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\taskat\build\iar\taskat_frdmk64f\taskat_frdmk64f.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\sem_lite\build\iar\sem_lite_frdmk64f\sem_lite_frdmk64f.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\sem\build\iar\sem_frdmk64f\sem_frdmk64f.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\nill_lite\build\iar\nill_lite_frdmk64f\nill_lite_frdmk64f.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\nill\build\iar\nill_frdmk64f\nill_frdmk64f.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\mutex_lite\build\iar\mutex_lite_frdmk64f\mutex_lite_frdmk64f.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\mutex\build\iar\mutex_frdmk64f\mutex_frdmk64f.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\msg_lite\build\iar\msg_lite_frdmk64f\msg_lite_frdmk64f.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\msg\build\iar\msg_frdmk64f\msg_frdmk64f.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\lwsem_lite\build\iar\lwsem_lite_frdmk64f\lwsem_lite_frdmk64f.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\lwsem\build\iar\lwsem_frdmk64f\lwsem_frdmk64f.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\lwmsgq_lite\build\iar\lwmsgq_lite_frdmk64f\lwmsgq_lite_frdmk64f.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\lwmsgq\build\iar\lwmsgq_frdmk64f\lwmsgq_frdmk64f.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\lwlog_lite\build\iar\lwlog_lite_frdmk64f\lwlog_lite_frdmk64f.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\lwlog\build\iar\lwlog_frdmk64f\lwlog_frdmk64f.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\lwevent_lite\build\iar\lwevent_lite_frdmk64f\lwevent_lite_frdmk64f.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\lwevent\build\iar\lwevent_frdmk64f\lwevent_frdmk64f.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\lwdemo_lite\build\iar\lwdemo_lite_frdmk64f\lwdemo_lite_frdmk64f.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\lwdemo\build\iar\lwdemo_frdmk64f\lwdemo_frdmk64f.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\log_lite\build\iar\log_lite_frdmk64f\log_lite_frdmk64f.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\log\build\iar\log_frdmk64f\log_frdmk64f.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\klog_lite\build\iar\klog_lite_frdmk64f\klog_lite_frdmk64f.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\klog\build\iar\klog_frdmk64f\klog_frdmk64f.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\isr_lite\build\iar\isr_lite_frdmk64f\isr_lite_frdmk64f.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\isr\build\iar\isr_frdmk64f\isr_frdmk64f.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\hello_lite\build\iar\hello_lite_frdmk64f\hello_lite_frdmk64f.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\hello\build\iar\hello_frdmk64f\hello_frdmk64f.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\event_lite\build\iar\event_lite_frdmk64f\event_lite_frdmk64f.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\event\build\iar\event_frdmk64f\event_frdmk64f.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\demo_lite\build\iar\demo_lite_frdmk64f\demo_lite_frdmk64f.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\demo\build\iar\demo_frdmk64f\demo_frdmk64f.ewp</path></project></workspace>
