<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
<batchBuild><batchDefinition><name>debug</name><member><project>mqx_stdlib_frdmk64f</project><configuration>debug</configuration></member><member><project>nshell_frdmk64f</project><configuration>debug</configuration></member><member><project>mqx_frdmk64f</project><configuration>debug</configuration></member></batchDefinition><batchDefinition><name>all</name><member><project>mqx_stdlib_frdmk64f</project><configuration>debug</configuration></member><member><project>mqx_stdlib_frdmk64f</project><configuration>release</configuration></member><member><project>nshell_frdmk64f</project><configuration>debug</configuration></member><member><project>nshell_frdmk64f</project><configuration>release</configuration></member><member><project>mqx_frdmk64f</project><configuration>debug</configuration></member><member><project>mqx_frdmk64f</project><configuration>release</configuration></member></batchDefinition><batchDefinition><name>release</name><member><project>mqx_stdlib_frdmk64f</project><configuration>release</configuration></member><member><project>nshell_frdmk64f</project><configuration>release</configuration></member><member><project>mqx_frdmk64f</project><configuration>release</configuration></member></batchDefinition></batchBuild><project><path>$WS_DIR$\..\..\..\mqx_stdlib\build\iar\mqx_stdlib_frdmk64f\mqx_stdlib_frdmk64f.ewp</path></project><project><path>$WS_DIR$\..\..\..\nshell\build\iar\nshell_frdmk64f\nshell_frdmk64f.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\build\iar\mqx_frdmk64f\mqx_frdmk64f.ewp</path></project></workspace>
